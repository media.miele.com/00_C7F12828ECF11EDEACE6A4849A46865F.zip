Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [COBie2.4DesignDeliverable]
File name: 0001
Time: 2024-01-10T12:26:22
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 21.1.21.45 - Exporter 21.1.21.45 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Wed Jan 10 12:26:22 2024 * Host: DEGTL11901 * Database: C:\Users\deschvi\AppData\Local\Temp\0cf60106-2a73-459f-b779-322d788a89f1\8617235f-1a43-4ba4-b052-9cae0f00433b\ifc * Database version: 5507 * Database creation date: Wed Jan 10 12:26:18 2024 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Wed Jan 10 12:26:19 2024 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Wed Jan 10 12:26:19 2024 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Pset_ProductRequirements - Category: Project Information

# IfcBuildingElementProxy: 12491120_RU_DAS4631_OBSW:28S4631B_RU_12491120_DAS4631_OBSW, (2)
In: Default
Type - Material: z_Miele_Design_Steel_Chrom
Type - Pset_BuildingElementProxyCommon - Reference: 28S4631B_RU_12491120_DAS4631_OBSW
Type - Pset_ProductRequirements - Category: Specialty Equipment
Type - Pset_QuantityTakeOff - Reference: 28S4631B_RU_12491120_DAS4631_OBSW
Material: z_Miele_Design_Steel_Chrom, z_Miele_Design_OBSW, z_Miele_Design_CLST, z_Miele_Design_Zinc_Steel, z_Miele_Connection_Electric, Plast
Pset_BuildingElementProxyCommon - sets with these values: 2

# IfcDistributionPort, Port_354279
Description: Flow; FlowDirection: SOURCEANDSINK
